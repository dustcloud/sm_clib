# IAR project Triangle2Manager.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\Libraries\MSP430FR2xx_4xx\; ..\Libraries\LCD\; ..\..\..\sm_clib\
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr4133.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  group (top)
    ./: main.c
  group Libraries/LCD
    ../Libraries/LCD/: hal_LCD.c hal_LCD.h
  group Libraries/MSP430FR2xx_4xx
    ../Libraries/MSP430FR2xx_4xx/: adc.c adc.h crc.c crc.h cs.c cs.h driverlib.h eusci_a_spi.c eusci_a_spi.h eusci_a_uart.c eusci_a_uart.h eusci_b_i2c.c eusci_b_i2c.h eusci_b_spi.c eusci_b_spi.h framctl.c framctl.h gpio.c gpio.h lcd_e.c lcd_e.h pmm.c pmm.h rtc.c rtc.h sfr.c sfr.h sysctl.c sysctl.h timer_a.c timer_a.h tlv.c tlv.h wdt_a.c wdt_a.h
  group Libraries/MSP430FR2xx_4xx/inc
    ../Libraries/MSP430FR2xx_4xx/inc/: hw_memmap.h hw_regaccess.h version.h
  group sm_clib
    ../../../sm_clib/: dn_clib_build.h dn_clib_version.h dn_common.h dn_endianness.h dn_hdlc.c dn_hdlc.h dn_ipmg.c dn_ipmg.h dn_ipmt.c dn_ipmt.h dn_lock.h dn_serial_mg.c dn_serial_mg.h dn_serial_mt.c dn_serial_mt.h dn_uart.h dn_whmt.c dn_whmt.h
  group sm_clib/ports/msp430fr4133
    ../../../sm_clib/ports/msp430fr4133/: dn_endianness.c dn_lock.c dn_uart.c
